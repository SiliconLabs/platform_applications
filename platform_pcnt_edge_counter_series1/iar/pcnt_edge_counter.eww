<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EFM32GG11_pcnt_edge_counter.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG12_pcnt_edge_counter.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32PG1_pcnt_edge_counter.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFM32TG11_pcnt_edge_counter.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG12_pcnt_edge_counter.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG13_pcnt_edge_counter.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32BG1_pcnt_edge_counter.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG12_pcnt_edge_counter.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG13_pcnt_edge_counter.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG14_pcnt_edge_counter.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32FG1_pcnt_edge_counter.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG12_pcnt_edge_counter.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG13_pcnt_edge_counter.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EFR32MG1_pcnt_edge_counter.ewp</path>
  </project>

  <batchBuild/>
</workspace>
