# IAR project xg21_spi_flash_read_bw_dma.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG21A020F1024IM32 SiliconLaboratories EFR32MG21A020F1024IM32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 57
  General.FPU2: 6
  ICCARM.CCDefines: STR(x)=#x; EFR32MG21A020F1024IM32; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\platform\CMSIS\Include; ..\..\..\platform\Device\SiliconLabs\EFR32MG21\Include; ..\..\..\platform\emlib\inc; ..\..\..\hardware\kit\EFR32MG21_BRD4180A\config; ..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\Drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFR32MG21A020F1024IM32; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: xg21_spi_flash_read_bw_dma.bin
  ILINK.IlinkOutputFile: xg21_spi_flash_read_bw_dma.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFR32MG21A020F1024IM32; RETARGET_VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NDEBUG; EFR32MG21A020F1024IM32; RETARGET_VCOM
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFR32MG21/Source/IAR/: startup_efr32mg21.s
    ../../../platform/Device/SiliconLabs/EFR32MG21/Source/: system_efr32mg21.c
  group emlib
    ../../../platform/CMSIS/emlib/src/: em_cmu.c em_core.c em_emu.c em_gpio.c em_ldma.c em_system.c em_usart.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
    ../Drivers/: systick.h systick.c
  group Source
    ../src/: main_dma.c
  group 
    ../: README.md
