<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\xg21_spi_flash_read_bw_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\xg21_spi_flash_read_bw_dma.ewp</path>
  </project>

  <batchBuild/>
</workspace>
