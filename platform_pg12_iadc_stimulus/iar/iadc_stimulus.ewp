# IAR project iadc_stimulus.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG12B500F1024GL125 SiliconLaboratories EFM32PG12B500F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STR(x)=#x; EFM32PG12B500F1024GL125
  ICCARM.CCIncludePath2: ..\..\..\platform\CMSIS\Include; ..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Include; ..\..\..\platform\emlib\inc; ..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config; ..\..\..\hardware\kit\common\bsp; ..\..\..\hardware\kit\common\drivers; ..\Drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: EFM32PG12B500F1024GL125
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: iadc_stimulus.bin
  ILINK.IlinkOutputFile: iadc_stimulus.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STR(x)=#x; EFM32PG12B500F1024GL125
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFM32PG12B/Source/IAR/: startup_efm32pg12b.s
    ../../../platform/Device/SiliconLabs/EFM32PG12B/Source/: system_efm32pg12b.c
  group emlib
    ../../../platform/emlib/src/: em_cmu.c em_core.c em_emu.c em_gpio.c em_system.c em_vdac.c
  group Drivers
    ../Drivers/: systick.h systick.c
  group Source
    ../src/: main.c
  group 
    ../: README.md
